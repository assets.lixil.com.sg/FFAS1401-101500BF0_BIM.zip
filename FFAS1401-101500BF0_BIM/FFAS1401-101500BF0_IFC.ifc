Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-01-14T10:58:21
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.1.109 - Exporter 21.1.1.109 - Alternate UI 21.1.1.109
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Jan 14 10:58:21 2024 * Host: LAPTOP-TVR8NT0T * Database: C:\Users\user\AppData\Local\Temp\cb292adb-013e-46ca-a64c-b5e7d75fd791\de599a38-c2b0-4487-9fbb-9d555e4767fa\ifc * Database version: 5507 * Database creation date: Sun Jan 14 10:58:20 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Jan 14 10:58:21 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Jan 14 10:58:21 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFlowTerminal: FFAS1401-101500BF0_REVIT:Concept SH Basin MXR W/ PUW, FFAS1401-101500BF0_REVIT:Concept SH Basin MXR W/ PUW:42067
In: Level 1
Type - Material: Steel, Chrome Plated
Type - Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: Concept SH Basin MXR W/ PUW
Pset_DistributionFlowElementCommon - Reference: Concept SH Basin MXR W/ PUW; sets with these values: 2
